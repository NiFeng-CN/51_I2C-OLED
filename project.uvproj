# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AI8051U-8Bit Series AI
  cpu: IRAM(0-0xFF) XRAM(0-0x7FFF) IROM(0-0xFFFF) CLOCK(35000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c iic.h iic.c oled.h oled.c
